# Keil uVision project maya4test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: maya4test
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: BIT_MATH.h GPIO_interface.h GPIO_Private.h GPIO_program.c GPS.h GPS_prog.c LCD_config.h LCD_int.h LCD_priv.h LCD_prog.c.c main.c startup_TM4C123.s STD_TYPES.h system_TM4C123.c systick_config.h systick_interface.h systick_Private.h systick_program.c tm4c123gh6pm.h UART_configuration.h UART_interface.h UART_private.h UART_program.c buzzer.h buzzer_copy.c
